<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>148.70912e6</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>149.9e6*0+148.709e6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>2,3,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>max</key><value>149.9e6*0+148.80e6</value></param>
<param><key>min</key><value>149.9e6*0+148.60e6</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gainIF</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gainIF</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>8</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>1,4,1,3</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>30</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gainRF</value></param>
<param><key>value</key><value>17</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gainRF</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>17</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>1,7,1,3</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>30</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gains</value></param>
<param><key>value</key><value>"RF=" + str(gainRF)+ " dB - " + "IF=" + str(gainIF) + " dB - "</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>prefix</value></param>
<param><key>value</key><value>"/home/dasl/UAV-RT/CURRENT_DATA/"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>recfile</value></param>
<param><key>value</key><value>prefix + gains + datetime.now().strftime("%Y-%m-%d-T%H.%M.%S") + ' - ' + datetime.now().strftime('%s.%f')[:-3] + ".dat"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2500000</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>choices</key><value>[2500000, 10000000]</value></param>
<param><key>value</key><value>2500000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid_pos</key><value>2,6,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>recfile</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_sink_x</key>
<param><key>id</key><value>blocks_vector_sink_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>7</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>datetime</value></param>
<param><key>import</key><value>from datetime import datetime</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>gainIF</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>gainRF</value></param>
<param><key>args</key><value>airspy=0,pack=1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>2500000</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>time</value></param>
<param><key>import</key><value>import time</value></param>
</block>
<block>
<key>timesync_pixstream_source</key>
<param><key>id</key><value>timesync_pixstream_source_0</value></param>
<param><key>telem_file_path</key><value>/home/dasl/UAV-RT/CURRENT_DATA</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>timesync_pixstream_source_0</source_block_id><sink_block_id>blocks_vector_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
